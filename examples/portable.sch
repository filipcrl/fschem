** sch_path: examples/portable.sch
**.subckt portable
R1 net1 net2 {R
R2 net2 0 {2*R
V1 net1 0 {VDD
**.ends
.end
